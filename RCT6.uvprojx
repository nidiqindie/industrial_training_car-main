# Keil uVision project RCT6.uvprojx, settings and files
target RCT6 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  output: RCT6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .;Libraries\CMSIS;User;Libraries\FWlib\inc;User\Led;User\beep;User\Key;User\usart;User\Timer;User\delay;User\GpioRemap;User\motor;User\APP;User\adc;User\servo;User\k210;User\serial;.cmsis\include;Project\F103RCT6_BspTemplate\RTE\_F103C8T6_BspTemplate;User\jy61p;User\oled\oled_software;RTE\_RCT6
  asm define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    User/Led/: bsp_led.c
    User/beep/: bsp_beep.c
    User/Key/: bsp_key.c
    User/usart/: bsp_usart.c
    User/Timer/: bsp_pwm.c
    User/delay/: bsp_delay.c
    User/GpioRemap/: bsp_GpioRemap.c
    User/motor/: bsp_motor.C board.c board.h Emm_V5.c Emm_V5.h delay.c delay.h fifo.c fifo.h
    User/APP/: app.c
    User/adc/: bsp_adc.c
    User/servo/: servo.c servo.h
    User/k210/: HMI.c HMI.h Serial_k210.c Serial_k210.cpp Serial_k210.h
    User/serial/: Serial.c Serial.cpp Serial.h
    User/jy61p/: REG.h wit_c_sdk.c wit_c_sdk.h jy61p.c jy61p.h
    User/oled/oled_software/: OLED.c OLED.h OLED_Font.h
